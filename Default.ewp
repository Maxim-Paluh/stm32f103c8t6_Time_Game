# IAR project Default.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: CMSIS\Core; CMSIS\Device\inc; User\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Default.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: CMSIS\Flash\stm32f103x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS/Core
    CMSIS/Core/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
  group CMSIS/Device/inc
    CMSIS/Device/inc/: stm32f103xb.h stm32f1xx.h system_stm32f1xx.h
  group CMSIS/Device/src
    CMSIS/Device/src/: startup_stm32f103xb.s system_stm32f1xx.c
  group Temp
    Temp/: temp.txt
  group User/inc
    User/inc/: Animation.h config.h led.h melody.h rcc.h time.h
  group User/src
    User/src/: Animation.c config.c led.c main.c melody.c rcc.c
